# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: project
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=1
  c include: ..\Lib_MCU\inc;..\Lib_BSP\inc;.\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group system
    ./: startup_LPC11xx.s
    ../Lib_MCU/src/: core_cm0.c system_LPC11xx.c
  group Peripheral
    ../Lib_MCU/src/: gpio.c uart.c retarget.c ssp.c i2c.c
  group Board
    ../Lib_BSP/src/: tools.c oled2864.c
  group User
    ./src/: main.c lpc11c14_it.c
