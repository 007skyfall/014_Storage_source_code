# Keil uVision project RFID.uvproj, settings and files
target UART (ARM-ADS)
  device: LPC1111/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x1FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC1111_RFID +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: ..\Common\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup
    ./: startup_LPC11xx.s
  group Cmsis
    ../Common/src/: core_cm0.c system_LPC11xx.c
  group Common
    ../Common/src/: uart.c retarget.c gpio.c ssp.c
  group Source
    ../src/: main.c RC522.c
