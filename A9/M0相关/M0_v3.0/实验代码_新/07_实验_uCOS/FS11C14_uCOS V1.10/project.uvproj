# Keil uVision project project.uvproj, settings and files
target FS11C14_uCOS (ARM-ADS)
  device: LPC11C14x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Full +hex
  c flags: Optim=1
  c include: ..\Lib_MCU\inc;..\Lib_BSP\inc;..\uCOS-II_V291\CPU;..\uCOS-II_V291\Source;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group System
    ../Lib_MCU/src/: startup_LPC11xx.s core_cm0.c system_LPC11xx.c
  group Peripheral
    ../Lib_MCU/src/: gpio.c uart.c retarget.c timer32.c
  group Board
    ../Lib_BSP/src/: key.c seg7led.c
  group uCOS-II
    ../uCOS-II_V291/CPU/: os_cpu_a.s os_cpu_c.c
    ../uCOS-II_V291/Source/: os_tmr.c os_core.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group User
    ./src/: main.c lpc11c14_it.c speaker_op.c
