# Keil uVision project project.uvproj, settings and files
target ZigBee_Prj (ARM-ADS)
  device: LPC1114x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ZigBee_Prj +hex
  c flags: Optim=1
  c include: ..\Lib_MCU\inc;..\Lib_BSP\inc;.\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group System
    ../Lib_MCU/src/: core_cm0.c system_LPC11xx.c
    ../../../程序源码/M0/Cortex-M0_Item_Src(仓库1)/V4.0-Cortex-M0_Item_Src(仓库1)/Lib_MCU/src/: startup_LPC11xx.s
  group Peripheral
    ../Lib_MCU/src/: clkconfig.c gpio.c uart.c retarget.c timer32.c ssp.c i2c.c can.c adc.c
  group Board
    ../Lib_BSP/src/: tools.c key.c seg7led.c oled2864.c temp_hum.c light.c acc.c rfid.c spi_uart.c
  group User
    ./src/: main.c can_pgm.c menu.c sensor.c led_spk_fan.c lpc11c14_it.c speaker_op.c
