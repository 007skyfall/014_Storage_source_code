# Keil uVision project project.uvproj, settings and files
target SSP (ARM-ADS)
  device: LPC1114x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: SSP +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .\inc;..\Common\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ../Common/src/: startup_LPC11xx.s
  group CMSIS
    ../Common/src/: core_cm0.c system_LPC11xx.c
  group Common
    ../Common/src/: gpio.c retarget.c uart.c
  group User
    ./src/: main.c ssp.c
